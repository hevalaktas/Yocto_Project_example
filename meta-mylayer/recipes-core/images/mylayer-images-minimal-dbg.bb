require mylayer-images-minimal.bb

DESCRIPTION = "A small mylayer image just capable of allowing a device to boot and \
is suitable for development work."

IMAGE_FEATURES += "dbg-pkgs"