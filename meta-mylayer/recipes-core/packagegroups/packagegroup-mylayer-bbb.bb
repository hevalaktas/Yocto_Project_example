SUMMARY = "Mylayer bbb"
PR = "r1"

LICENSE= "MIT"

inherit packagegroup

RDEPENDS_${PN} = " bbb-example"