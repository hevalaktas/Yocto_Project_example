require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "A small image just conaining a calculator" 

IMAGE_FEATURES += "bc"

